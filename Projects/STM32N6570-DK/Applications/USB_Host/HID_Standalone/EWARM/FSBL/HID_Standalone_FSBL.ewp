# IAR project HID_Standalone_FSBL.ewp, settings and files
configuration HID_Standalone_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; TCPP0203_SUPPORT
  ICCARM.CCIncludePath2: ..\..\FSBL\Core\Inc; ..\..\FSBL\USB_Host\App; ..\..\FSBL\USB_Host\Target; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\Components\tcpp0203; ..\..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_Standalone_FSBL.bin
  ILINK.IlinkOutputFile: HID_Standalone_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/Core
    ../../FSBL/Core/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Application/User/USB_Host/App
    ../../FSBL/USB_Host/App/: keyboard.c mouse.c usb_host.c
  group Application/User/USB_Host/Target
    ../../FSBL/USB_Host/Target/: usbh_conf.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/STM32N6570-DK
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_usbpd_pwr.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_adc.c stm32n6xx_hal_adc_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_hcd.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_ll_adc.c stm32n6xx_ll_usb.c
  group Middlewares/STM32_USBH_Library/Class/HID
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
