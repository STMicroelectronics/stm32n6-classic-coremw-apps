# Keil uVision project FatFs_RAMDISK_Standalone_FSBL.uvprojx, settings and files
target FatFs_RAMDISK_Standalone_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: FatFs_RAMDISK_Standalone_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx
  c include: ../../FSBL/Core/Inc;../../../../../../../Drivers/BSP/STM32N6xx_Nucleo;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Middlewares/Third_Party/FatFs/source;../../FSBL/FATFS/App;../../FSBL/FATFS/Target;..\..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source\drivers\sram
  library: MicroLIB
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT5: ROM 0xc07e000 size 0x2000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/Core
    ../../FSBL/Core/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Application/User/FATFS/App
    ../../FSBL/FATFS/App/: app_fatfs.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32N6xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffunicode.c ffsystem_baremetal.c
  group Middlewares/FatFs/Drivers
    ../../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sram/: sram_diskio.c
software components: CMSIS:CORE 5.6.0
